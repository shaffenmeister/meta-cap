CFLAGS:append:armv6 = " -DMISSING_64BIT_ATOMICS"
