PACKAGECONFIG:append = " pcre ssl ssh2 libz"
