FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

CFLAGS:append = " -DSQLITE_ENABLE_UNLOCK_NOTIFY"
